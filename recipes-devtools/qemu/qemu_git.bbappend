
PACKAGECONFIG[gvtg] = "--enable-vgt,--disable-vgt"

